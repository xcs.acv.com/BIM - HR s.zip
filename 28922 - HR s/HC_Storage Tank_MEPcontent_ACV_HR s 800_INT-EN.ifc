Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2021-06-29T09:50:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 29 09:50:25 2021 * Host: MBACIU-RO-DE * Database: C:\Users\MBaciu\AppData\Local\Temp\{1FEF09CA-4B14-400A-8DD5-C4F026992B6E}\ifc * Database version: 5507 * Database creation date: Tue Jun 29 09:50:24 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Jun 29 09:50:25 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 29 09:50:25 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Constraints(Type) - Elevation Base: Project Base Point

# IfcTank: HR s 800, HC_Storage Tank_MEPcontent_ACV_HR s_320-1000_INT-EN:HR s 800:1330778
In: V00
Type - Material: Color RGB 222-222-222, Color RGB 237-028-036, Color RGB 040-040-040, Color RGB 155-155-155
Type - Dimensions - Depth: 980 mm; Domestic Cold Water Diameter: 38.1 mm; Domestic Hot Water Auxiliary Diameter: 38.1 mm; Domestic Hot Water Diameter: 38.1 mm; Height: 1955 mm; Hydronic Return Diameter: 50.8 mm; Hydronic Supply Diameter: 50.8 mm; Use Nominal Diameter: yes; Width: 980 mm
Type - Electrical - Frequency: 50 Hz; Maximum Supply Power: 1300 W; Rated Current (Fuse): 6 A; Voltage: 230 V
Type - Identity Data - Article Type: HR s 800; Base Family Version: 12.29; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Fast recovery stainless steel tank-in-tank cylinder; EMCS Version: 4.0; ETIM Article Class: EC011392; Family Version: 12.17; GLN: 5400891000007; Manufacturer: ACV; Manufacturer URL: https://www.acv.com/international/customer/dl/910; MEPcontent Class: STORAGE_TANK_HC; Model: HR s 800; OmniClass Number: 23.75.10.34.11; OmniClass Title: Energy Storage Tanks; Revit Version: 2018; Type Name: HR s 800; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Grey: Color RGB 155-155-155
Type - Mechanical - DHW Continuous Flow 60°C: 0.0003875 m3/s; Maximum Supply Temperature (Operating Temperature): 85 kg/K/s3; Max Pressure DHW: 860000 Pa; Max Pressure Heating: 400000 Pa; Total Capacity: 0.8 m3; Weight: 261
Type - Other - Category: Mechanical Equipment; Back Geometry: 1009 mm; Base Diameter: 780 mm; C: 335 mm; Connector Length: 29 mm; Connector Position: 125 mm; D: 1585 mm; E: 360 mm; E Radius: 180 mm; Family Name: HC_Storage Tank_MEPcontent_ACV_HR s_320-1000_INT-EN; Logo Position: 489.7 mm
Type - Text - Article Description: Fast recovery stainless steel tank-in-tank cylinder; GTIN: 5400891002032; Manufacturer Art. No.: 06633001; Product Line: HR
Pset_ManufacturerTypeInformation - Manufacturer: ACV
Constraints - Offset: 0 mm
Dimensions - Area: 16.6542 m2; Volume: 1.41652 m3
Identity Data - Mark: 4
Mechanical - Domestic Cold Water Flow: 0 m3/s; Domestic Hot Water Auxiliary Flow: 0 m3/s; Domestic Hot Water Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; System Classification: Domestic Hot Water,Domestic Cold Water,Hydronic Supply,Hydronic Return,Power
Other - Back Clearance Safe: 1000 mm; Family: HC_Storage Tank_MEPcontent_ACV_HR s_320-1000_INT-EN: HR s 800; Family and Type: HC_Storage Tank_MEPcontent_ACV_HR s_320-1000_INT-EN: HR s 800; Left Clearance Safe: 1000 mm; Top Clearance Safe: 300 mm; Type: HC_Storage Tank_MEPcontent_ACV_HR s_320-1000_INT-EN: HR s 800; Type Id: HC_Storage Tank_MEPcontent_ACV_HR s_320-1000_INT-EN: HR s 800
Phasing - Phase Created: 3. Nieuwbouw
Visibility - Back Clearance: 1000 mm; Left Clearance: 1000 mm; Service Space: no; Top Clearance: 300 mm
